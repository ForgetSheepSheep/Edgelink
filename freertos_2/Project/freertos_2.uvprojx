# Keil uVision project freertos_2.uvprojx, settings and files
target freertos_2 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F303ZE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: IRAM(0x20000000,0x010000) IROM(0x08040000,0x00038000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: freertos_2
  AfterMake: fromelf --bin --output="Objects\@L.bin" "Objects\@L.axf"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: COMPONENT_BOOT_AB_CURRENT_SLOT=COMPONENT_BOOT_AB_SLOT_B,APP_VECTOR_ADDR=0x08040000UL
  c include: ..\Library\Include;..\Middleware\ThirdParty\FreeRTOS\include;..\Middleware\ThirdParty\FreeRTOS\portable\RVDS\ARM_CM4F;..\Startup;..\User;..\RTT_Debug;..\Libs;..\Bsp;..\Application;..\Device
  library: MicroLIB
  memory RVCT4: ROM 0x8040000 size 0x38000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/: main.c gd32f30x_it.c
  group Application
    ../Application/app_lcd_plan_page/: app_lcd_plan_page.c
    ../Application/app_modbus/: app_modbus.c
    ../Application/app_net/: app_net.c
    ../Application/app_boot_ab/: app_boot_ab.c boot_param.c
    ../Application/app_ota/: app_ota.c app_ota_worker.c
    ../Application/app_fw_nvs/: fw_nvs.c
    ../Application/app_ota_dl/: ota_dl.c
    ../Application/app_ui_snapshot/: app_ui_snapshot.c
  group Device
    ../Device/dev_sram/: dev_sram.c
    ../Device/dev_lcd/: dev_lcd.c
    ../Device/dev_gt911/: dev_gt911.c
    ../Device/dev_at24c02/: dev_at24c02.c
    ../Device/dev_gd25q128/: dev_gd25q128.c
    ../Device/dev_flash/: dev_flash.c
    ../Device/dev_net/: dev_net.c
    ../Device/dev_lora/: dev_lora.c dev_lora_protocol.c
  group Bsp
    ../Bsp/bsp_delay/: bsp_delay.c
    ../Bsp/bsp_fwdgt/: bsp_fwdgt.c
    ../Bsp/bsp_gpio/: bsp_gpio.c
    ../BSP/bsp_fsmc/: bsp_fsmc.c
    ../Bsp/bsp_iic/: bsp_iic.c
    ../Bsp/bsp_spi/: bsp_spi.c
    ../Bsp/bsp_uart/: bsp_uart.c
    ../Bsp/bsp_wwdgt/: bsp_wwdgt.c
    ../BSP/bsp_flash/: bsp_flash.c
  group Middleware/FreeRTOS
    ../Middleware/ThirdParty/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middleware/ThirdParty/FreeRTOS/portable/MemMang/: heap_4.c
    ../Middleware/ThirdParty/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group Middleware/modbus_rtu
    ../Middleware/modbus_rtu/: modbus_crc.c modbus_frame.h modbus_port.h
    ../Middleware/modbus_rtu/modbus_master/: modbus_master.c modbus_master.h modbus_master_config.h
  group Middleware/modbus_rtu/prot
    ../Middleware/modbus_rtu/prot/: port_serial.c port_timer.c
  group Library
    ../Library/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group Startup
    ../Startup/: system_gd32f30x.c startup_gd32f30x_hd.s
  group RTT_Debug
    ../RTT_Debug/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Libs
    ../Libs/ring_buffer/: ring_buffer.c
    ../Libs/cJSON/: cJSON.c
    ../Libs/ota_crc/: ota_crc.c
