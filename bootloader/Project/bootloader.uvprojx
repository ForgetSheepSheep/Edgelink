# Keil uVision project bootloader.uvprojx, settings and files
target bootloader (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F303ZE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bootloader +hex
  AfterMake: fromelf --bin --output=Objects\@L.bin Objects\@L.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32F30X_HD
  c include: ..\Application;..\BSP;..\Config;..\Device;..\Library\Include;..\Startup;..\RTT_Debug
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/: main.c
  group Application
    ../Application/: bootloader.c boot_ota.c boot_status.c boot_param.c
    ../Application/ota_crc/: ota_crc.c
  group BSP
    ../BSP/bsp_flash/: bsp_flash.c
    ../BSP/bsp_delay/: bsp_delay.c
    ../BSP/bsp_fsmc/: bsp_fsmc.c
    ../BSP/bsp_gpio/: bsp_gpio.c
    ../BSP/bsp_iic/: bsp_iic.c
    ../BSP/bsp_spi/: bsp_spi.c
    ../BSP/bsp_systick/: bsp_systick.c
    ../BSP/bsp_fwdgt/: bsp_fwdgt.c
    ../BSP/bsp_wwdgt/: bsp_wwdgt.c
  group Device
    ../Device/dev_flash/: dev_flash.c
    ../Device/dev_lcd/: dev_lcd.c
    ../Device/dev_at24c02/: dev_at24c02.c
    ../Device/dev_gd25q128/: dev_gd25q128.c
  group Library
    ../Library/Source/: gd32f30x_fmc.c gd32f30x_exmc.c gd32f30x_gpio.c gd32f30x_rcu.c gd32f30x_spi.c gd32f30x_fwdgt.c gd32f30x_wwdgt.c
  group Startup
    ../Startup/: system_gd32f30x.c startup_gd32f30x_hd.s
  group RTT_Debug
    ../RTT_Debug/: SEGGER_RTT.c SEGGER_RTT_printf.c
